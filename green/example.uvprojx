# Keil uVision project example.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C6 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2800) IROM(0x08000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: example +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Library;.\Start;.\User;.\System\Public;.\System\delay;.\System\Timer;.\Hardware\bluetooth;.\Hardware\sys;.\Hardware\oled;.\Hardware\serial;.\Hardware\servo_motor;.\Hardware\beep;.\Hardware\led;.\Hardware\ray;.\System\Dma;.\User\pid;.\System\pwm;.\Hardware\joystick
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Library
    ./Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group System
    ./System/Public/: public.c public.h
    ./System/Dma/: dma.c dma.h
    ./System/delay/: Delay.c Delay.h
    ./System/Timer/: Timer.c Timer.h
    ./System/pwm/: Pwm.c Pwm.h
  group Hardware
    ./Hardware/bluetooth/: bluetooth.c bluetooth.h
    ./Hardware/oled/: oled.c oled.h OLED_Font.h
    ./Hardware/servo_motor/: servo_motor.c servo_motor.h
    ./Hardware/serial/: usart.c usart.h
    ./Hardware/beep/: beep.c beep.h
    ./Hardware/led/: led.c led.h
    ./Hardware/joystick/: joystick.c joystick.h
  group User
    ./User/: stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h main.c
    ./User/pid/: pid.c pid.h
